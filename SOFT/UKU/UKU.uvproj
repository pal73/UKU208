# Keil uVision project UKU.uvproj, settings and files
target UKU208 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: UKU208 +hex
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group HTTP
    ./WEB/: web.inp
  group Startup
    ./: startup_LPC17xx.s Net_Config_HTTP.c
  group Source
    ./: common_func.c mess.c ret.c gran.c cmd.h main.c simbols.c graphic.c riverdi.c
  group System
    ./: system_LPC17xx.c Timer.c
  group Target
    ./: beep.c 25lc640SSP1.c
  group Connecting
    ./: uart0.c
  group Library
    C:/Keil/ARM/Boards/Keil/MCB1700/RL/TCPnet/Library/: EMAC_LPC17xx.c
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib
    ./: FT_CoPro_Cmds.c FT_Gpu_Hal.c
